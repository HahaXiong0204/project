# Keil uVision project stm32.uvprojx, settings and files
target AlarmClock (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, USE_STM3210C_EVAL
  c include: ..\inc;..\..\Utilities\STM32_EVAL;..\..\Utilities\STM32_EVAL\STM3210C_EVAL;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\src\STM32App\485;..\src\STM32App\sci;..\src\STM32App\nvic;..\src\STM32App\led;..\src\STM32App\timer;..\src\STM32App\DMA;..\src\STM32App\RCC;..\src\STM32App\MBSlave;..\src\STM32App\ADC;..\src\STM32App\crc;..\src\STM32App\CC;..\src\STM32App\Displacement;..\src\STM32App\Calibration;..\src\STM32App\Flash;..\src\STM32App\FRDGL;..\src\STM32App\temperature;..\NET\device;..\NET\MQTT;..\NET\onenet;..\NET\delay;..\NET\sys;..\NET\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../src/STM32App/: main.c 1602.C
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group RVMDK
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group STM32F10x_StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_usart.c
  group NET
    ../NET/device/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/: onenet.c
    ../NET/delay/: delay.c
    ../NET/sys/: sys.c
    ../NET/usart/: usart.c
software components: CMSIS:CORE 5.1.1
