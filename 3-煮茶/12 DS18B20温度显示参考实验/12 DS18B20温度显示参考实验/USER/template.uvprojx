# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\FWLIB\inc;..\CORE;..\DELAY;..\HARDWARE\LED;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\KEY;..\TFT;..\GUI;..\HARDWARE\ds18b20
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group DELAY
    ../DELAY/: delay.c
  group TFT
    ../TFT/: tft.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/ds18b20/: ds18b20.c
  group GUI
    ../GUI/: GUI.C
software components: CMSIS:CORE 5.1.1
