# Keil uVision project onenet_mqtt_demo.uvprojx, settings and files
target onenet_mqtt_demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: onenet_mqtt_demo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,USE_FULL_LL_DRIVER
  c include: ../Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc;    ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;    ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;    ../Drivers/CMSIS/Include;    ..\NET\device\inc;    ..\NET\MQTT;    ..\NET\onenet\inc;    ..\HardWare\DHT11;    ..\HardWare\HC_SR04;    ..\HardWare\Lighting;    ..\HardWare\OLED;    ..\HardWare\voice
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c i2c.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usart.c stm32f1xx_ll_gpio.c stm32f1xx_ll_dma.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group NET
    ../NET/device/src/: esp8266.c
    ../NET/MQTT/: MqttKit.c
    ../NET/onenet/src/: onenet.c
  group HardWare
    ../HardWare/DHT11/: dht11.c
    ../HardWare/HC_SR04/: HC_SR04.c
    ../HardWare/Lighting/: lighting.c
    ../HardWare/OLED/: oled.c
    ../HardWare/voice/: voice.c
    ../HardWare/: 引脚说明.txt
software components: CMSIS:CORE 4.3.0
